# Keil uVision project ATK_ESP8266.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ATK_ESP8266 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\ATK-ESP8266;..\CORE;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\USART3;..\MALLOC;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\DSP;..\HARDWARE\AD;..\HARDWARE\Encoder;..\HARDWARE\LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c mqtt_port.c mqtt_port.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/AD/: AD.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/Encoder/: Encoder.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_wwdg.c
  group MALLOC
    ../MALLOC/: malloc.c
  group ATK_ESP8266
    ../ATK-ESP8266/: apsta.c common.c wifiap.c wifista.c
  group DSP
    ../DSP/: cr4_fft_256_stm32.s cr4_fft_1024_stm32.s stm32_dsp.h table_fft.h
software components: Data Exchange:JSON:cJSON 1.7.7, IoT Utility:MQTTPacket 1.1.0
